PACKAGECONFIG:append = " gstreamer pulseaudio"

QT_DEFAULT_MEDIA_BACKEND = "gstreamer"
